# Keil uVision project car.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: car +hex
  group Source Group 1
    ./: delay.c delay.h hw.c hw.h LED.c LED.h main.c motor.c motor.h sr04.c sr04.h timer.c timer.h uart1.c uart1.h
